#include "TextRenderer.h"
#include <string.h>

// ── Font Data ─────────────────────────────────────────────────────────────────
// 5 bytes per character, one byte per column, LSB = topmost pixel (row 0).
// Range: ASCII 0x20 (' ') to 0x5A ('Z'), 59 entries.
// Exactly matches leddite_client.py FONT dict, extended with ':', '-', '.'.
//
// Special chars within the 0x20–0x5A range:
//   0x20 ' '  0x21 '!'  0x2D '-'  0x2E '.'  0x3A ':'
//   0x3F '?'  0x41–0x5A A–Z
// All others (punctuation 0x22–0x2C, 0x2F, 0x3B–0x3E, 0x40) default to space.

const uint8_t TextRenderer::FONT_DATA[][5] = {
    // 0x20 ' '
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x21 '!'
    {0x00, 0x00, 0x5F, 0x00, 0x00},
    // 0x22 '"'  — not supported, render as space
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x23 '#'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x24 '$'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x25 '%'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x26 '&'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x27 '''  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x28 '('  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x29 ')'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x2A '*'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x2B '+'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x2C ','  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x2D '-'
    {0x00, 0x08, 0x08, 0x08, 0x00},
    // 0x2E '.'
    {0x00, 0x60, 0x60, 0x00, 0x00},
    // 0x2F '/'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x30 '0'
    {0x3E, 0x51, 0x49, 0x45, 0x3E},
    // 0x31 '1'
    {0x00, 0x42, 0x7F, 0x40, 0x00},
    // 0x32 '2'
    {0x42, 0x61, 0x51, 0x49, 0x46},
    // 0x33 '3'
    {0x21, 0x41, 0x45, 0x4B, 0x31},
    // 0x34 '4'
    {0x18, 0x14, 0x12, 0x7F, 0x10},
    // 0x35 '5'
    {0x27, 0x45, 0x45, 0x45, 0x39},
    // 0x36 '6'
    {0x3C, 0x4A, 0x49, 0x49, 0x30},
    // 0x37 '7'
    {0x01, 0x71, 0x09, 0x05, 0x03},
    // 0x38 '8'
    {0x36, 0x49, 0x49, 0x49, 0x36},
    // 0x39 '9'
    {0x06, 0x49, 0x49, 0x29, 0x1E},
    // 0x3A ':'
    {0x00, 0x36, 0x36, 0x00, 0x00},
    // 0x3B ';'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x3C '<'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x3D '='  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x3E '>'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x3F '?'
    {0x02, 0x01, 0x51, 0x09, 0x06},
    // 0x40 '@'  — not supported
    {0x00, 0x00, 0x00, 0x00, 0x00},
    // 0x41 'A'
    {0x7E, 0x11, 0x11, 0x11, 0x7E},
    // 0x42 'B'
    {0x7F, 0x49, 0x49, 0x49, 0x36},
    // 0x43 'C'
    {0x3E, 0x41, 0x41, 0x41, 0x22},
    // 0x44 'D'
    {0x7F, 0x41, 0x41, 0x22, 0x1C},
    // 0x45 'E'
    {0x7F, 0x49, 0x49, 0x49, 0x41},
    // 0x46 'F'
    {0x7F, 0x09, 0x09, 0x09, 0x01},
    // 0x47 'G'
    {0x3E, 0x41, 0x49, 0x49, 0x7A},
    // 0x48 'H'
    {0x7F, 0x08, 0x08, 0x08, 0x7F},
    // 0x49 'I'
    {0x00, 0x41, 0x7F, 0x41, 0x00},
    // 0x4A 'J'
    {0x20, 0x40, 0x41, 0x3F, 0x01},
    // 0x4B 'K'
    {0x7F, 0x08, 0x14, 0x22, 0x41},
    // 0x4C 'L'
    {0x7F, 0x40, 0x40, 0x40, 0x40},
    // 0x4D 'M'
    {0x7F, 0x02, 0x0C, 0x02, 0x7F},
    // 0x4E 'N'
    {0x7F, 0x04, 0x08, 0x10, 0x7F},
    // 0x4F 'O'
    {0x3E, 0x41, 0x41, 0x41, 0x3E},
    // 0x50 'P'
    {0x7F, 0x09, 0x09, 0x09, 0x06},
    // 0x51 'Q'
    {0x3E, 0x41, 0x51, 0x21, 0x5E},
    // 0x52 'R'
    {0x7F, 0x09, 0x19, 0x29, 0x46},
    // 0x53 'S'
    {0x46, 0x49, 0x49, 0x49, 0x31},
    // 0x54 'T'
    {0x01, 0x01, 0x7F, 0x01, 0x01},
    // 0x55 'U'
    {0x3F, 0x40, 0x40, 0x40, 0x3F},
    // 0x56 'V'
    {0x1F, 0x20, 0x40, 0x20, 0x1F},
    // 0x57 'W'
    {0x3F, 0x40, 0x38, 0x40, 0x3F},
    // 0x58 'X'
    {0x63, 0x14, 0x08, 0x14, 0x63},
    // 0x59 'Y'
    {0x07, 0x08, 0x70, 0x08, 0x07},
    // 0x5A 'Z'
    {0x61, 0x51, 0x49, 0x45, 0x43},
};

// ── Private helpers ───────────────────────────────────────────────────────────

const uint8_t* TextRenderer::getGlyph(char c) {
    // Upper-case normalisation: accept lowercase a–z
    if (c >= 'a' && c <= 'z') c = c - 'a' + 'A';

    uint8_t idx = (uint8_t)c;
    if (idx < FONT_MIN_CHAR || idx > FONT_MAX_CHAR) {
        // Unsupported — return space glyph (index 0 in FONT_DATA)
        return FONT_DATA[0];
    }
    return FONT_DATA[idx - FONT_MIN_CHAR];
}

// ── Public API ────────────────────────────────────────────────────────────────

uint16_t TextRenderer::textWidth(const char* text) {
    if (!text) return 0;
    return (uint16_t)(strlen(text) * CHAR_STRIDE);
}

uint32_t TextRenderer::bufferSize(const char* text) {
    if (!text) return 0;
    return (uint32_t)textWidth(text) * CHAR_HEIGHT * 3;
}

void TextRenderer::renderText(const char* text, uint8_t* outPixels,
                               uint16_t& outW, uint16_t& outH,
                               const uint8_t* color) {
    outW = 0;
    outH = CHAR_HEIGHT;

    if (!text || !outPixels) return;

    size_t len = strlen(text);
    if (len == 0) return;

    outW = (uint16_t)(len * CHAR_STRIDE);

    // Zero-fill the buffer first
    uint32_t totalBytes = (uint32_t)outW * outH * 3;
    for (uint32_t i = 0; i < totalBytes; i++) outPixels[i] = 0;

    // Render each character
    for (size_t charIdx = 0; charIdx < len; charIdx++) {
        const uint8_t* glyph = getGlyph(text[charIdx]);
        uint16_t charX = (uint16_t)(charIdx * CHAR_STRIDE);

        for (uint8_t col = 0; col < CHAR_WIDTH; col++) {
            uint8_t colByte = glyph[col];
            for (uint8_t row = 0; row < CHAR_HEIGHT; row++) {
                if ((colByte >> row) & 0x01) {
                    uint16_t px = charX + col;
                    uint16_t py = row;
                    uint32_t pixelIdx = ((uint32_t)py * outW + px) * 3;
                    outPixels[pixelIdx + 0] = color[0]; // R
                    outPixels[pixelIdx + 1] = color[1]; // G
                    outPixels[pixelIdx + 2] = color[2]; // B
                }
            }
        }
        // Column CHAR_WIDTH (index 5) in each character slot remains 0 (gap) — already zeroed
    }
}
